<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\A2015132039CYU_UARTS.ewp</path>
  </project>
  <batchBuild />
</workspace>
